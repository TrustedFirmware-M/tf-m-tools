# Keil uVision project tfm_s.uvprojx, settings and files
target FVP (6150000::V6.15::ARMCLANG)
  device: SMM-SSE-200 ARM
  pack: ARM.V2M-MPS2_SSE_200_BSP.2.0.0
  cpu: IRAM(0x30000000,0x00200000) IRAM2(0x20000000,0x00200000) IROM(0x10000000,0x00400000) IROM2(0x00000000,0x00400000) CPUTYPE("Cortex-M33") TZ CLOCK(12000000) ESEL ELITTLE
  output: tfm_s
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DAUTH_NONE SECURE_UART1
  c include: .\cmsis_drivers;.\native_drivers;.\native_drivers\timer_cmsdk;.\RTE\Device\SMM-SSE-200
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT5: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x30000000 size 0x200000
  memory RVCT10: RAM 0x20000000 size 0x200000
  scatter file: .\RTE\TFM\tfm_common_s.sct
  link misc: --import_cmse_lib_out="Objects/tfm_s_CMSE_Lib.o"
--predefine="-include tfm_config.h"
--predefine="-include tfm_config_rte.h"
--predefine="-IRTE/_FVP/"
--predefine="-IRTE/TFM_Platform/SMM-SSE-200/"
--diag_suppress=L6312,L6314,6329
  group System Code
    ./RTE/Device/SMM-SSE-200/: startup_cmsdk_mps2_an521_s.s system_cmsdk_mps2_an521.c platform_retarget_dev.c
    ./native_drivers/: mpc_sie200_drv.c arm_uart_drv.c
    ./native_drivers/timer_cmsdk/: timer_cmsdk.c
    ./cmsis_drivers/: Driver_Flash.c Driver_MPC.c Driver_USART.c
software components: Board Support:Common 1.0.0, CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, Device:Startup 2.0.0, Security:mbed TLS 2.24.0, TFM Platform:Attest HAL:Template 1.2.0, TFM Platform:Boot Seed:Dummy 1.2.0, TFM Platform:Crypto Keys:Dummy 1.2.0, TFM Platform:Device ID:Dummy 1.2.0, TFM Platform:Memory Map 1.2.0, TFM Platform:NV Counters:Dummy 1.2.0, TFM Platform:SPM HAL:Platform 1.0.0, TFM Platform:System:Template 1.0.0, TFM Platform:Test:Platform 1.0.0, TFM:Core 1.2.0, TFM:Library:QCBOR 1.2.0, TFM:Library:T_COSE 1.2.0, TFM:Secure Service:Audit Logging 1.2.0, TFM:Secure Service:Crypto 1.2.0, TFM:Secure Service:Initial Attestation 1.2.0, TFM:Secure Service:Internal Trusted Storage 1.2.0, TFM:Secure Service:Platform 1.2.0, TFM:Secure Service:Protected Storage 1.2.0, TFM:Test Service:Core 1.2.0, TFM:Test Service:IRQ 1.2.0, TFM:Test Service:PS 1.2.0, TFM:Test Service:Secure Client 1.2.0, TFM:Test:Attestation 1.2.0, TFM:Test:Audit 1.2.0, TFM:Test:Crypto 1.2.0, TFM:Test:Framework 1.2.0, TFM:Test:ITS 1.2.0, TFM:Test:PS 1.2.0, TFM:Test:Platform 1.2.0
