# Keil uVision project tfm_ns.uvprojx, settings and files
target FVP (6150000::V6.15::ARMCLANG)
  device: SMM-SSE-200 ARM
  pack: ARM.V2M-MPS2_SSE_200_BSP.2.0.0
  cpu: IRAM(0x30000000,0x00200000) IRAM2(0x20000000,0x00200000) IROM(0x10000000,0x00400000) IROM2(0x00000000,0x00400000) CPUTYPE("Cortex-M33") TZ CLOCK(12000000) ESEL ELITTLE
  output: tfm_ns +hex
  AfterMake: image.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\tfm_s\native_drivers;..\tfm_s\native_drivers\timer_cmsdk;.\RTE\Device\SMM-SSE-200
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT5: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x30000000 size 0x200000
  memory RVCT10: RAM 0x20000000 size 0x200000
  scatter file: .\RTE\Device\SMM-SSE-200\mps2_an521_ns.sct
  group Source Code
    ./RTE/Device/SMM-SSE-200/: startup_cmsdk_mps2_an521_ns.s system_cmsdk_mps2_an521.c platform_retarget_dev.c
    ./: main.c
  group CMSE_Lib
    ../tfm_s/Objects/: tfm_s_CMSE_Lib.o
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 2.0.0, TFM:API:Crypto 1.2.0, TFM:API:Initial Attestation 1.2.0, TFM:API:Internal Trusted Storage 1.2.0, TFM:API:Protected Storage 1.2.0, TFM:Core 1.2.0
