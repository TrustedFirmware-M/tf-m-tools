# Keil uVision project bl2.uvprojx, settings and files
target FVP (6150000::V6.15::ARMCLANG)
  device: SMM-SSE-200 ARM
  pack: ARM.V2M-MPS2_SSE_200_BSP.2.0.0
  cpu: IRAM(0x30000000,0x00200000) IRAM2(0x20000000,0x00200000) IROM(0x10000000,0x00400000) IROM2(0x00000000,0x00400000) CPUTYPE("Cortex-M33") TZ CLOCK(12000000) ESEL ELITTLE
  output: bl2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\native_drivers;.\native_drivers\timer_cmsdk;.\RTE\Device\SMM-SSE-200
  memory RVCT4: ROM 0x10000000 size 0x400000
  memory RVCT5: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x30000000 size 0x200000
  memory RVCT10: RAM 0x20000000 size 0x200000
  scatter file: .\RTE\Device\SMM-SSE-200\mps2_an521_bl2.sct
  link misc: --diag_suppress=L6312,L6848
  group System Code
    ./RTE/Device/SMM-SSE-200/: startup_cmsdk_mps2_an521_bl2.s system_cmsdk_mps2_an521.c platform_retarget_dev.c
    ./native_drivers/: arm_uart_drv.c
    ./cmsis_drivers/: Driver_Flash.c Driver_USART.c
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, Security:mbed TLS 2.24.0, TFM Platform:Boot HAL:Platform 1.0.0, TFM Platform:Crypto Keys:Dummy 1.2.0, TFM Platform:Memory Map 1.2.0, TFM Platform:NV Counters:Dummy 1.2.0, TFM:Bootloader 1.2.0
